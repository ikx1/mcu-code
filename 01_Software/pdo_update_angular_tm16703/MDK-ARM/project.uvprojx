# Keil uVision project project.uvprojx, settings and files
target 双轮差速 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Core\Inc;..\Drivers\inc;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\port\RVDS\ARM_CM3;..\Middlewares\FreeRTOS\port\MemMang;..\Middlewares\components\FIFO;..\Middlewares\components\lib_function;..\Middlewares\components\can_queue;..\Middlewares\components\filter;..\Middlewares\components\host_protocol;..\BSP_Plantform\Bsp_Drivers\battery\driver;..\BSP_Plantform\Bsp_Drivers\battery\handler;..\BSP_Plantform\Bsp_Drivers\display\driver;..\BSP_Plantform\Bsp_Drivers\display\handler;..\BSP_Plantform\Bsp_Drivers\io\driver;..\BSP_Plantform\Bsp_Drivers\ibus\driver;..\BSP_Plantform\Bsp_Drivers\ibus\handler;..\BSP_Plantform\Bsp_Drivers\motor\driver;..\BSP_Plantform\Bsp_Drivers\motor\handler;..\BSP_Plantform\Bsp_Drivers\communication\driver;..\BSP_Plantform\Bsp_Drivers\ultrasonic_sensor\driver;..\BSP_Plantform\Bsp_Drivers\ws2812\driver;..\BSP_Plantform\Bsp_Drivers\wdt\driver;..\BSP_Plantform\Bsp_Integration\uart;..\MCU_Platform\MCU_Core_CAN;..\MCU_Platform\MCU_Core_GPIO;..\MCU_Platform\MCU_Core_IRQ;..\MCU_Platform\MCU_Core_PWM;..\MCU_Platform\MCU_Core_UART;..\MCU_Platform\MCU_Core_WDT;..\User\User_Init;..\User\motor_task;..\User\control_task;..\User\ibus_task;..\User\communication_task;..\User\io_task;..\User\battery_task;..\User\ws2812_task;..\User\wdt_task;..\DebugComponent\easylogger\inc;..\DebugComponent\SEGGER_RTT\RTT;..\DebugComponent;..\SystemConfig
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User/Core
    ../Core/Src/: main.c can.c spi.c stm32f10x_it.c uart.c gpio.c delay.c tim.c iwdg.c
  group Drivers/STM32F10x_StdPeriph_Driver
    ../Drivers/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Middlewares/FreeRTOS
    ../Middlewares/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/FreeRTOS/port/RVDS/ARM_CM3/: port.c
    ../Middlewares/FreeRTOS/port/MemMang/: heap_4.c
  group Middlewares/components
    ../Middlewares/components/lib_function/: user_function.c
    ../Middlewares/components/can_queue/: canopen_proto.c can_queue.c
    ../Middlewares/components/host_protocol/: host_protocol.c
    ../Middlewares/components/filter/: speed_filter.c
    ../Middlewares/components/FIFO/: fifo.c
  group Debug/RTT
    ../DebugComponent/SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../DebugComponent/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../DebugComponent/easylogger/port/: elog_port.c
    ../DebugComponent/: Debug.c
  group SystemConfig
    ../SystemConfig/: system_cfg.h
  group MCU_Platform
    ../MCU_Platform/MCU_Core_CAN/: can_port.c can_irq_adapter.c
    ../MCU_Platform/MCU_Core_GPIO/: gpio_port.c
    ../MCU_Platform/MCU_Core_IRQ/: serial_irq_router.c
    ../MCU_Platform/MCU_Core_PWM/: pwm_port.c
    ../MCU_Platform/MCU_Core_UART/: legacy_uart_port.c uart_irq_adapter.c uart_port.c
    ../MCU_Platform/MCU_Core_WDT/: wdt_port.c
  group BSP_Plantform/Bsp_Drivers
    ../BSP_Plantform/Bsp_Drivers/motor/driver/: bsp_motor_driver.c
    ../BSP_Plantform/Bsp_Drivers/motor/handler/: bsp_motor_handler.c
    ../BSP_Plantform/Bsp_Drivers/battery/driver/: bsp_battery_driver.c
    ../BSP_Plantform/Bsp_Drivers/battery/handler/: bsp_battery_handler.c
    ../BSP_Plantform/Bsp_Drivers/display/driver/: bsp_display_driver.c
    ../BSP_Plantform/Bsp_Drivers/display/handler/: bsp_handler_display.c
    ../BSP_Plantform/Bsp_Drivers/io/driver/: bsp_gpio_driver.c
    ../BSP_Plantform/Bsp_Drivers/ibus/driver/: bsp_ibus_driver.c
    ../BSP_Plantform/Bsp_Drivers/ibus/handler/: bsp_ibus_handler.c
    ../BSP_Plantform/Bsp_Drivers/ultrasonic_sensor/driver/: bsp_ultrasonic_driver.c
    ../BSP_Plantform/Bsp_Drivers/ws2812/driver/: bsp_ws2812_driver.c
    ../BSP_Plantform/Bsp_Drivers/wdt/driver/: bsp_driver_wdt.c
    ../BSP_Plantform/Bsp_Drivers/communication/driver/: bsp_uart_driver.c
    ../BSP_Plantform/Bsp_Integration/uart/: uart_rtos.c uart_stack.c
  group User
    ../User/User_Init/: User_Init.c
    ../User/motor_task/: motor_task.c
    ../User/control_task/: control_task.c
    ../User/ibus_task/: ibus_task.c
    ../User/communication_task/: uart_task.c telemetry_service.c
    ../User/io_task/: io_task.c
    ../User/battery_task/: battery_task.c
    ../User/ws2812_task/: ws2812_task.c
    ../User/wdt_task/: wdt_task.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0
