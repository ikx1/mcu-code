# Keil uVision project Car_Control.uvprojx, settings and files
target Car_Control (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Car_Control
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/components/can_queue;../Middlewares/components/FIFO;../Middlewares/components/lib_function;../Middlewares/components/filter;../Middlewares/components/host_protocol;..\SystemConfig;..\MCU_Platform\MCU_Core_IRQ;..\MCU_Platform\MCU_Core_UART;..\MCU_Platform\MCU_Core_GPIO;..\MCU_Platform\MCU_Core_CAN;..\MCU_Platform\MCU_Core_PWM;..\MCU_Platform\MCU_Core_WDT;../BSP_Plantform/Bsp_Drivers/battery/driver;../BSP_Plantform/Bsp_Drivers/battery/handler;../BSP_Plantform/Bsp_Drivers/communication/driver;../BSP_Plantform/Bsp_Drivers/display/driver;../BSP_Plantform/Bsp_Drivers/display/handler;../BSP_Plantform/Bsp_Drivers/ibus/driver;../BSP_Plantform/Bsp_Drivers/ibus/handler;../BSP_Plantform/Bsp_Drivers/io/driver;../BSP_Plantform/Bsp_Drivers/motor/driver;../BSP_Plantform/Bsp_Drivers/motor/handler;../BSP_Plantform/Bsp_Drivers/ultrasonic_sensor/driver;../BSP_Plantform/Bsp_Drivers/wdt/driver;../BSP_Plantform/Bsp_Drivers/ws2812/driver;..\BSP_Plantform\Bsp_Integration\uart;../User/User_Init;../User/motor_task;../User/communication_task;../User/ibus_task;../User/control_task;../User/io_task;../User/battery_task;../User/wdt_task;../User/ws2812_task;../DebugComponents/Cmbacktrace;../DebugComponents/Cmbacktrace/fault_handler/keil;../DebugComponents/sfud/inc
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_ll_usart.c stm32f4xx_ll_gpio.c stm32f4xx_ll_dma.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/Components
    ../Middlewares/components/can_queue/: can_queue.c canopen_proto.c
    ../Middlewares/components/lib_function/: user_function.c
    ../Middlewares/components/filter/: speed_filter.c
    ../Middlewares/components/FIFO/: fifo.c
  group SystemConfig
    ../SystemConfig/: system_cfg.h
  group MCU_Platform
    ../MCU_Platform/MCU_Core_IRQ/: serial_irq_router.c
    ../MCU_Platform/MCU_Core_UART/: uart_irq_adapter.c uart_port.c legacy_uart_port.c
    ../MCU_Platform/MCU_Core_GPIO/: gpio_port.c
    ../MCU_Platform/MCU_Core_CAN/: can_port.c can_irq_adapter.c
    ../MCU_Platform/MCU_Core_PWM/: pwm_port.c
    ../MCU_Platform/MCU_Core_WDT/: wdt_port.c
  group BSP_Plantform/Bsp_Drivers
    ../BSP_Plantform/Bsp_Drivers/battery/driver/: bsp_battery_driver.c
    ../BSP_Plantform/Bsp_Drivers/battery/handler/: bsp_battery_handler.c
    ../BSP_Plantform/Bsp_Drivers/communication/driver/: bsp_uart_driver.c
    ../BSP_Plantform/Bsp_Drivers/display/driver/: bsp_display_driver.c
    ../BSP_Plantform/Bsp_Drivers/display/handler/: bsp_handler_display.c
    ../BSP_Plantform/Bsp_Drivers/ibus/driver/: bsp_ibus_driver.c
    ../BSP_Plantform/Bsp_Drivers/ibus/handler/: bsp_ibus_handler.c
    ../BSP_Plantform/Bsp_Drivers/io/driver/: bsp_gpio_driver.c
    ../BSP_Plantform/Bsp_Drivers/motor/driver/: bsp_motor_driver.c
    ../BSP_Plantform/Bsp_Drivers/motor/handler/: bsp_motor_handler.c
    ../BSP_Plantform/Bsp_Drivers/ultrasonic_sensor/driver/: bsp_ultrasonic_driver.c
    ../BSP_Plantform/Bsp_Drivers/wdt/driver/: bsp_driver_wdt.c
    ../BSP_Plantform/Bsp_Drivers/ws2812/driver/: bsp_ws2812_driver.c
  group BSP_Plantform/Bsp_Integration
    ../Middlewares/components/host_protocol/: host_protocol.c
    ../BSP_Plantform/Bsp_Integration/uart/: uart_rtos.c uart_stack.c
  group User
    ../User/User_Init/: User_Init.c
    ../User/motor_task/: motor_task.c
    ../User/communication_task/: uart_task.c telemetry_service.c
    ../User/control_task/: control_task.c
    ../User/ibus_task/: ibus_task.c
    ../User/io_task/: io_task.c
    ../User/battery_task/: battery_task.c
    ../User/wdt_task/: wdt_task.c
    ../User/ws2812_task/: ws2812_task.c
software components: CMSIS:CORE 5.5.0
